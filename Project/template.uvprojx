# Keil uVision project template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Driver\delay;..\Driver\sys;..\Driver\usart;..\Driver\STM32f10x_FWLib\libraries\inc;..\Driver\STM32f10x_FWLib;..\Driver\LED;..\Driver\IIC;..\Driver\Motor
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Stm32F10x_CruxFile
    ../Driver/STM32f10x_FWLib/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Stm32F10x_FWLib
    ../Driver/STM32f10x_FWLib/libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c misc.c stm32f10x_i2c.c stm32f10x_tim.c
  group Driver
    ../Driver/delay/: delay.c
    ../Driver/sys/: sys.c
    ../Driver/usart/: usart.c
    ../Driver/LED/: led.c
  group User
    ../User/: main.c
  group OLED
    ../Driver/IIC/: OLED_I2C.c
    ../Driver/Motor/: motor.c
    ../Driver/tim/: tim.c
    ../Driver/systemtime/: systemtime.c
